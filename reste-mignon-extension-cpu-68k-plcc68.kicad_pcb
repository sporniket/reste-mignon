# Repository sporniket/reste-mignon (continued)

## KiCad design reste-mignon.kicad_pcb (continued)

Schematic: subsheet_301.kicad_sch, ReSTe mignon

Parts:
C303, C306, C307, C1601: 0.1uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
J301: DB-19S ACSI Port; DSUB-19_Female_Horizontal_P2.77x2.84mm_EdgePinOffset7.70mm_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
J1601: Like MegaSTE J402; PinHeader_2x15_P2.54mm_Vertical
RN1601, RN1602, RN1603: 68 ×4; R_Array_Convex_4x0603
U302: 74LS245_PHY; DIP-20_W7.62mm_LongPads
U306: 74LS74_PHY; DIP-14_W7.62mm_LongPads
U307: 74LS244_PHY; DIP-20_W7.62mm_LongPads

Connections:
/J301 — ACSI Port/HD0: J1601.2, U302.2 (A1)
/J301 — ACSI Port/HD1: J1601.4, U302.3 (A2)
/J301 — ACSI Port/HD2: J1601.6, U302.4 (A3)
/J301 — ACSI Port/HD3: J1601.8, U302.5 (A4)
/J301 — ACSI Port/HD4: J1601.10, U302.6 (A5)
/J301 — ACSI Port/HD5: J1601.12, U302.7 (A6)
/J301 — ACSI Port/HD6: J1601.14, U302.8 (A7)
/J301 — ACSI Port/HD7: J1601.16, U302.9 (A8)
/J301 — ACSI Port/acsi_12: J301.12, J1601.17, U307.9 (2Y1)
/J301 — ACSI Port/hd_enable: U302.19 (~OE), U306.6 (~1Q)
/J301 — ACSI Port/hda0: J1601.20, RN1603.3 (R3.1), U307.7 (2Y2)
/J301 — ACSI Port/hdack: J1601.18, RN1603.2 (R2.1), U307.3 (2Y4)
/J301 — ACSI Port/hdcs: J1601.19, RN1603.1 (R1.1), U307.5 (2Y3)
/J301 — ACSI Port/hdrw: J1601.21, RN1603.4 (R4.1), U307.12 (1Y4)
ACSI_19_HDRQ: J301.19, J1601.22; also elsewhere on the board
BD0SEL: U307.18 (1Y1); also elsewhere on the board
CADDR1: U307.13 (2A2); also elsewhere on the board
CDATA0: U302.18 (B1); also elsewhere on the board
CDATA1: U302.17 (B2); also elsewhere on the board
CDATA2: U302.16 (B3); also elsewhere on the board
CDATA3: U302.15 (B4); also elsewhere on the board
CDATA4: U302.14 (B5); also elsewhere on the board
CDATA5: U302.13 (B6); also elsewhere on the board
CDATA6: U302.12 (B7); also elsewhere on the board
CDATA7: U302.11 (B8); also elsewhere on the board
CLK8: U306.3 (1CLK); also elsewhere on the board
D0SEL: U307.2 (1A1); also elsewhere on the board
DMA_ACK: U307.17 (2A4); also elsewhere on the board
DMA_FDCS: U306.1 (~1CLR), U306.2 (1D); also elsewhere on the board
DMA_HDCS: U307.15 (2A3); also elsewhere on the board
DMA_RW: U302.1 (DIR), U307.8 (1A4); also elsewhere on the board
GND: C303.2, C306.2, C307.2, C1601.2, J301.11, J301.13, J301.15, J301.17, J301.SH (Shield), J1601.25, J1601.27, J1601.29, U302.10 (GND), U306.7 (GND), U306.10 (~2PRE), U306.11 (2CLK), U306.12 (2D), U307.1 (~1G), U307.10 (GND), U307.19 (~2G); also elsewhere on the board
unnamed: J301.1, RN1601.8 (R1.2)
unnamed: J301.2, RN1601.7 (R2.2)
unnamed: J301.3, RN1601.6 (R3.2)
unnamed: J301.4, RN1601.5 (R4.2)
unnamed: J301.5, RN1602.8 (R1.2)
unnamed: J301.6, RN1602.7 (R2.2)
unnamed: J301.7, RN1602.6 (R3.2)
unnamed: J301.8, RN1602.5 (R4.2)
unnamed: J301.9, RN1603.8 (R1.2)
unnamed: J301.14, RN1603.7 (R2.2)
unnamed: J301.16, RN1603.6 (R3.2)
unnamed: J301.18, RN1603.5 (R4.2)
unnamed: J1601.1, RN1601.1 (R1.1)
unnamed: J1601.3, RN1601.2 (R2.1)
unnamed: J1601.5, RN1601.3 (R3.1)
unnamed: J1601.7, RN1601.4 (R4.1)
unnamed: J1601.9, RN1602.1 (R1.1)
unnamed: J1601.11, RN1602.2 (R2.1)
unnamed: J1601.13, RN1602.3 (R3.1)
unnamed: J1601.15, RN1602.4 (R4.1)
VCC: C303.1, C306.1, C307.1, C1601.1, J1601.26, J1601.28, J1601.30, U302.20 (Vcc), U306.4 (~1PRE), U306.13 (~2CLR), U306.14 (Vcc), U307.20 (Vcc); also elsewhere on the board
XHDINT: J301.10, J1601.23; also elsewhere on the board
XRESET: U307.11 (2A1); also elsewhere on the board

Notes on the sheet:
This connector is the same as in the MegaSTE (J402). One could plug the harddisk controller C103561-001
TODO : verify how to wire unused flip flop

Schematic: subsheet_303.kicad_sch, ReSTe mignon

Parts:
C300, C301: 0.1uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
U303: 8.010613 MHz; Oscillator_DIP-14
U304: 74LS74_PHY; DIP-14_W7.62mm_LongPads

Connections:
/U303 — SCLK & CLK2 clocks/half_sclk: U304.5 (1Q), U304.11 (2CLK)
CLK2: U304.9 (2Q); also elsewhere on the board
GND: C300.2, C301.2, U303.7 (GND), U304.7 (GND); also elsewhere on the board
unnamed: U304.2 (1D), U304.6 (~1Q)
unnamed: U304.8 (~2Q), U304.12 (2D)
SCLK: U303.8 (OUT), U304.3 (1CLK); also elsewhere on the board
VCC: C300.1, C301.1, U303.14 (Vcc), U304.1 (~1CLR), U304.4 (~1PRE), U304.10 (~2PRE), U304.13 (~2CLR), U304.14 (Vcc); also elsewhere on the board

Notes on the sheet:
To YM2149 and MFP 68901
To WD1772 and Shifter

Schematic: subsheet_400.kicad_sch, ReSTe mignon

Parts:
C402, C403, C404, C405, C406: 0.1uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
J1901: ROM[0..6] Breakout; PinSocket_2x07_P2.54mm_Vertical
R421: 1K; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
RN1901, RN1902: 33 ×4; R_Array_Convex_4x0603
RN1903, RN1904, RN1905: 68 ×4; R_Array_Convex_4x0603
U400: STE_GSTMCU_PHY; PQFP-144_28x28mm_P0.65mm

Connections:
/U400 — GSTMCU/cas0h: RN1901.2 (R2.1), U400.126 (~CAS0H)
/U400 — GSTMCU/cas0l: RN1901.3 (R3.1), U400.125 (~CAS0L)
/U400 — GSTMCU/cas1h: RN1902.2 (R2.1), U400.123 (~CAS1H)
/U400 — GSTMCU/cas1l: RN1902.3 (R3.1), U400.122 (~CAS1L)
/U400 — GSTMCU/ma0: RN1905.2 (R2.1), U400.110 (MAD0)
/U400 — GSTMCU/ma1: RN1905.1 (R1.1), U400.111 (MAD1)
/U400 — GSTMCU/ma2: RN1904.4 (R4.1), U400.112 (MAD2)
/U400 — GSTMCU/ma3: RN1904.3 (R3.1), U400.113 (MAD3)
/U400 — GSTMCU/ma4: RN1904.2 (R2.1), U400.114 (MAD4)
/U400 — GSTMCU/ma5: RN1904.1 (R1.1), U400.115 (MAD5)
/U400 — GSTMCU/ma6: RN1903.4 (R4.1), U400.116 (MAD6)
/U400 — GSTMCU/ma7: RN1903.3 (R3.1), U400.117 (MAD7)
/U400 — GSTMCU/ma8: RN1903.2 (R2.1), U400.118 (MAD8)
/U400 — GSTMCU/ma9: RN1903.1 (R1.1), U400.119 (MAD9)
/U400 — GSTMCU/ras0: RN1901.1 (R1.1), U400.127 (~RAS0)
/U400 — GSTMCU/ras1: RN1902.1 (R1.1), U400.124 (~RAS1)
/U400 — GSTMCU/rom0: J1901.1, U400.7 (~ROM0)
/U400 — GSTMCU/rom1: J1901.3, U400.8 (~ROM1)
/U400 — GSTMCU/rom5: J1901.11, U400.12 (~ROM5)
/U400 — GSTMCU/rom6: J1901.13, U400.13 (~ROM6)
/U400 — GSTMCU/we: RN1902.4 (R4.1), U400.121 (~WE)
ADDR1: U400.65 (A1); also elsewhere on the board
ADDR2: U400.64 (A2); also elsewhere on the board
ADDR3: U400.63 (A3); also elsewhere on the board
ADDR4: U400.62 (A4); also elsewhere on the board
ADDR5: U400.61 (A5); also elsewhere on the board
ADDR6: U400.59 (A6); also elsewhere on the board
ADDR7: U400.58 (A7); also elsewhere on the board
ADDR8: U400.57 (A8); also elsewhere on the board
ADDR9: U400.56 (A9); also elsewhere on the board
ADDR10: U400.55 (A10); also elsewhere on the board
ADDR11: U400.54 (A11); also elsewhere on the board
ADDR12: U400.53 (A12); also elsewhere on the board
ADDR13: U400.52 (A13); also elsewhere on the board
ADDR14: U400.51 (A14); also elsewhere on the board
ADDR15: U400.50 (A15); also elsewhere on the board
ADDR16: U400.49 (A16); also elsewhere on the board
ADDR17: U400.47 (A17); also elsewhere on the board
ADDR18: U400.46 (A18); also elsewhere on the board
ADDR19: U400.45 (A19); also elsewhere on the board
ADDR20: U400.44 (A20); also elsewhere on the board
ADDR21: U400.43 (A21); also elsewhere on the board
ADDR22: U400.42 (A22); also elsewhere on the board
ADDR23: U400.41 (A23); also elsewhere on the board
CLK4: U400.4 (CLK4); also elsewhere on the board
CLK8: U400.3 (CLK8); also elsewhere on the board
DATA0: U400.91 (D0); also elsewhere on the board
DATA1: U400.90 (D1); also elsewhere on the board
DATA2: U400.89 (D2); also elsewhere on the board
DATA3: U400.88 (D3); also elsewhere on the board
DATA4: U400.87 (D4); also elsewhere on the board
DATA5: U400.86 (D5); also elsewhere on the board
DATA6: U400.85 (D6); also elsewhere on the board
DATA7: U400.84 (D7); also elsewhere on the board
DATA8: U400.82 (D8); also elsewhere on the board
DATA9: U400.81 (D9); also elsewhere on the board
DATA10: U400.80 (D10); also elsewhere on the board
DATA11: U400.79 (D11); also elsewhere on the board
DATA12: U400.78 (D12); also elsewhere on the board
DATA13: U400.77 (D13); also elsewhere on the board
DATA14: U400.76 (D14); also elsewhere on the board
DATA15: U400.75 (D15); also elsewhere on the board
DE: U400.141 (DE); also elsewhere on the board
FC0: U400.40 (FC0); also elsewhere on the board
FC1: U400.39 (FC1); also elsewhere on the board
FC2: U400.38 (FC2); also elsewhere on the board
FDINT: U400.16 (FDINT); also elsewhere on the board
GND: C402.2, C403.2, C404.2, C405.2, C406.2, J1901.2, J1901.4, J1901.6, J1901.8, J1901.10, J1901.12, J1901.14, U400.1 (GND), U400.37 (GND), U400.73 (GND), U400.74 (TEST), U400.109 (GND), U400.128 (GND); also elsewhere on the board
HSYNC: U400.143 (~HSYNC); also elsewhere on the board
JOYWL: U400.102 (JOYWL); also elsewhere on the board
KHZ500: U400.6 (CLK0.5); also elsewhere on the board
MADDR0: RN1905.7 (R2.2); also elsewhere on the board
MADDR1: RN1905.8 (R1.2); also elsewhere on the board
MADDR2: RN1904.5 (R4.2); also elsewhere on the board
MADDR3: RN1904.6 (R3.2); also elsewhere on the board
MADDR4: RN1904.7 (R2.2); also elsewhere on the board
MADDR5: RN1904.8 (R1.2); also elsewhere on the board
MADDR6: RN1903.5 (R4.2); also elsewhere on the board
MADDR7: RN1903.6 (R3.2); also elsewhere on the board
MADDR8: RN1903.7 (R2.2); also elsewhere on the board
MADDR9: RN1903.8 (R1.2); also elsewhere on the board
MCU_BLANK: U400.140 (~BLANK); also elsewhere on the board
MCU_CMPCS: U400.139 (~CMPCS); also elsewhere on the board
MCU_DCYC: U400.138 (~DCYC); also elsewhere on the board
MCU_LATCH: U400.131 (LATCH); also elsewhere on the board
MCU_RDAT: U400.130 (~RDAT); also elsewhere on the board
MCU_SLOAD: U400.106 (~SLOAD); also elsewhere on the board
MCU_WDAT: U400.129 (~WDAT); also elsewhere on the board
N6850: U400.48 (6850); also elsewhere on the board
RDY: U400.135 (~RDY); also elsewhere on the board
RXW: U400.70 (R/~W); also elsewhere on the board
SHIFTER_16MHZ: U400.2 (CLK16); also elsewhere on the board
SHIFTER_SREQ: U400.107 (SREQ); also elsewhere on the board
SNDCS: U400.19 (SNDCS); also elsewhere on the board
SNDIR: U400.18 (SNDIR); also elsewhere on the board
VCC: C402.1, C403.1, C404.1, C405.1, C406.1, R421.1, U400.30 (~EINT3), U400.31 (~EINT5), U400.32 (~EINT7), U400.36 (VCC), U400.72 (VCC), U400.108 (VCC), U400.120 (VCC), U400.144 (VCC); also elsewhere on the board
VSYNC: U400.142 (~VSYNC); also elsewhere on the board
XAS: U400.67 (~AS); also elsewhere on the board
XBERR: U400.23 (~BERR); also elsewhere on the board
XBGK: U400.26 (~BGACK); also elsewhere on the board
XBLTBG: U400.28 (~BGI); also elsewhere on the board
XBLTINT: U400.60 (~BINT); also elsewhere on the board
XBR: U400.29 (~BR); also elsewhere on the board
XBUTTON: U400.103 (~BUTTON); also elsewhere on the board
XCAS0H: RN1901.7 (R2.2); also elsewhere on the board
XCAS0L: RN1901.6 (R3.2); also elsewhere on the board
XCAS1H: RN1902.7 (R2.2); also elsewhere on the board
XCAS1L: RN1902.6 (R3.2); also elsewhere on the board
XDISKINT: U400.17 (~DISKINT); also elsewhere on the board
XDTACK: U400.71 (~DTACK); also elsewhere on the board
XFCS: U400.136 (~FCS); also elsewhere on the board
XHDINT: R421.2, U400.15 (~HDINT); also elsewhere on the board
XIACK: U400.83 (~IACK); also elsewhere on the board
XIPL0: U400.33 (~IPL0); also elsewhere on the board
XIPL1: U400.34 (~IPL1); also elsewhere on the board
XIPL2: U400.35 (~IPL2); also elsewhere on the board
XJOYRH: U400.99 (~JOYRH); also elsewhere on the board
XJOYRL: U400.100 (~JOYRL); also elsewhere on the board
XJOYWE: U400.101 (~JOYWE); also elsewhere on the board
XLDS: U400.69 (~LDS); also elsewhere on the board
XMFPCS: U400.92 (~MFPCS); also elsewhere on the board
XMFPINT: U400.93 (~MFPINT); also elsewhere on the board
XPAD0X: U400.94 (~PAD0X); also elsewhere on the board
XPAD0Y: U400.95 (~PAD0Y); also elsewhere on the board
XPAD1X: U400.96 (~PAD1X); also elsewhere on the board
XPAD1Y: U400.97 (~PAD1Y); also elsewhere on the board
XPADRST: U400.98 (~PADRST); also elsewhere on the board
XPEN: U400.137 (~PEN); also elsewhere on the board
XRAS0: RN1901.8 (R1.2); also elsewhere on the board
XRAS1: RN1902.8 (R1.2); also elsewhere on the board
XRESET: U400.66 (~RESET); also elsewhere on the board
XROM2: J1901.5, U400.9 (~ROM2); also elsewhere on the board
XROM3: J1901.7, U400.10 (~ROM3); also elsewhere on the board
XROM4: J1901.9, U400.11 (~ROM4); also elsewhere on the board
XSINT: U400.105 (~SINT); also elsewhere on the board
XUDS: U400.68 (~UDS); also elsewhere on the board
XVMA: U400.24 (~VMA); also elsewhere on the board
XVPA: U400.25 (~VPA); also elsewhere on the board
XWE: RN1902.5 (R4.2); also elsewhere on the board

Schematic: subsheet_401.kicad_sch, ReSTe mignon

Parts:
C412, C413: 0.1uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
H2001, H2002, H2003, H2004: M2.5; MountingHole_2.7mm_M2.5_clear_10mm
J2001: For RGB2HDMI; PinHeader_2x10_P2.54mm_Vertical
R411, R416, R422: 12K; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R412, R417, R424: 1K5; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R414, R418, R426: 3K; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R415, R419, R428: 6K2; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R430: 1K; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
U401: STE_GSTSHIFTER_PHY; PLCC-84_THT-Socket

Connections:
/U401 — GST Shifter/b0: J2001.5, R415.2, U401.49 (B0)
/U401 — GST Shifter/b1: J2001.6, R414.2, U401.48 (B1)
/U401 — GST Shifter/b2: J2001.7, R412.2, U401.47 (B2)
/U401 — GST Shifter/b3: J2001.8, R411.2, U401.46 (B3)
/U401 — GST Shifter/g0: J2001.9, R419.2, U401.45 (G0)
/U401 — GST Shifter/g1: J2001.10, R418.2, U401.44 (G1)
/U401 — GST Shifter/g2: J2001.11, R417.2, U401.43 (G2)
/U401 — GST Shifter/g3: J2001.12, R416.2, U401.42 (G3)
/U401 — GST Shifter/mono: J2001.3, J2001.4, R430.2, U401.50 (MONO)
/U401 — GST Shifter/r0: J2001.13, R428.2, U401.41 (R0)
/U401 — GST Shifter/r1: J2001.14, R426.2, U401.40 (R1)
/U401 — GST Shifter/r2: J2001.15, R424.2, U401.39 (R2)
/U401 — GST Shifter/r3: J2001.16, R422.2, U401.38 (R3)
ADDR1: U401.17 (A1); also elsewhere on the board
ADDR2: U401.16 (A2); also elsewhere on the board
ADDR3: U401.15 (A3); also elsewhere on the board
ADDR4: U401.14 (A4); also elsewhere on the board
ADDR5: U401.13 (A5); also elsewhere on the board
ADDR6: U401.12 (A6); also elsewhere on the board
DATA0: U401.78 (D0); also elsewhere on the board
DATA1: U401.79 (D1); also elsewhere on the board
DATA2: U401.80 (D2); also elsewhere on the board
DATA3: U401.81 (D3); also elsewhere on the board
DATA4: U401.82 (D4); also elsewhere on the board
DATA5: U401.83 (D5); also elsewhere on the board
DATA6: U401.84 (D6); also elsewhere on the board
DATA7: U401.1 (D7); also elsewhere on the board
DATA8: U401.2 (D8); also elsewhere on the board
DATA9: U401.3 (D9); also elsewhere on the board
DATA10: U401.4 (D10); also elsewhere on the board
DATA11: U401.5 (D11); also elsewhere on the board
DATA12: U401.6 (D12); also elsewhere on the board
DATA13: U401.7 (D13); also elsewhere on the board
DATA14: U401.8 (D14); also elsewhere on the board
DATA15: U401.9 (D15); also elsewhere on the board
DE: U401.54 (~DE); also elsewhere on the board
FCLK: U401.34 (FCLK); also elsewhere on the board
GND: C412.2, C413.2, J2001.18, J2001.20, U401.73 (LOWP), U401.74 (GND), U401.75 (GND); also elsewhere on the board
HSYNC: J2001.1; also elsewhere on the board
MC: U401.53 (CLK); also elsewhere on the board
MCU_BLANK: U401.55 (~BLANK); also elsewhere on the board
MCU_CMPCS: U401.18 (~CS); also elsewhere on the board
MCU_DCYC: U401.37 (~LOAD); also elsewhere on the board
MCU_LATCH: U401.76 (LATCH); also elsewhere on the board
MCU_RDAT: U401.77 (~RDAT); also elsewhere on the board
MCU_SLOAD: U401.35 (~SLOAD); also elsewhere on the board
MCU_WDAT: U401.72 (~WDAT); also elsewhere on the board
MDATA0: U401.56 (MD0); also elsewhere on the board
MDATA1: U401.57 (MD1); also elsewhere on the board
MDATA2: U401.58 (MD2); also elsewhere on the board
MDATA3: U401.59 (MD3); also elsewhere on the board
MDATA4: U401.60 (MD4); also elsewhere on the board
MDATA5: U401.61 (MD5); also elsewhere on the board
MDATA6: U401.62 (MD6); also elsewhere on the board
MDATA7: U401.63 (MD7); also elsewhere on the board
MDATA8: U401.64 (MD8); also elsewhere on the board
MDATA9: U401.65 (MD9); also elsewhere on the board
MDATA10: U401.66 (MD10); also elsewhere on the board
MDATA11: U401.67 (MD11); also elsewhere on the board
MDATA12: U401.68 (MD12); also elsewhere on the board
MDATA13: U401.69 (MD13); also elsewhere on the board
MDATA14: U401.70 (MD14); also elsewhere on the board
MDATA15: U401.71 (MD15); also elsewhere on the board
MWD: U401.30 (MWD); also elsewhere on the board
MWK: U401.31 (MWK); also elsewhere on the board
RXW: U401.10 (R/~W); also elsewhere on the board
SCLK: U401.33 (SCLK); also elsewhere on the board
SD0: U401.28 (SD0); also elsewhere on the board
SD1: U401.27 (SD1); also elsewhere on the board
SD2: U401.26 (SD2); also elsewhere on the board
SD3: U401.25 (SD3); also elsewhere on the board
SD4: U401.24 (SD4); also elsewhere on the board
SD5: U401.23 (SD5); also elsewhere on the board
SD6: U401.22 (SD6); also elsewhere on the board
SHIFTER_16MHZ: U401.52 (CLK16); also elsewhere on the board
SHIFTER_BLUE: R411.1, R412.1, R414.1, R415.1; also elsewhere on the board
SHIFTER_GREEN: R416.1, R417.1, R418.1, R419.1; also elsewhere on the board
SHIFTER_MONO: R430.1; also elsewhere on the board
SHIFTER_RED: R422.1, R424.1, R426.1, R428.1; also elsewhere on the board
SHIFTER_SD7: U401.21 (SD7); also elsewhere on the board
SHIFTER_SREQ: U401.36 (SREQ); also elsewhere on the board
VCC: C412.1, C413.1, J2001.17, J2001.19, U401.11 (VCC), U401.32 (VCC); also elsewhere on the board
VSYNC: J2001.2; also elsewhere on the board
XLD: U401.19 (~LD); also elsewhere on the board
XMWE: U401.29 (~MWE); also elsewhere on the board
XRD: U401.20 (~RD); also elsewhere on the board

Notes on the sheet:
Inverted by U211
Master Clock from U405

Schematic: subsheet_302.kicad_sch, ReSTe mignon

Parts:
C304, C305: 0.1uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
J302: Internal FDD Power; Molex_KK-254_AE-6410-04A_1x04_P2.54mm_Vertical
J303: Internal FDD Port; IDC-Header_2x17_P2.54mm_Vertical
J304: DIN-14S — External FDD Port; socket-din-14
J1701: Jumpers; PinHeader_2x02_P2.54mm_Vertical
R302, R1701: 1K; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R307: 220; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
RN1701, RN1702, RN1704: 1K ×4; R_Array_Convex_4x0603
RN1703: 47 ×4; R_Array_Convex_4x0603
U301: WD1772_FLOPPY_DISK_CONTROLLER_AND_FORMATTER_PHY; DIP-28_W15.24mm_LongPads
U305: 7406_PHY; DIP-14_W7.62mm_LongPads
W300, W301: SW_SPDT; PinHeader_1x03_P2.54mm_Vertical

Connections:
/U301 — WD1772 and port/+12V: J302.4
/U301 — WD1772 and port/DRV_DOIN: J303.18, J304.9, RN1703.1 (R1.1)
/U301 — WD1772 and port/DRV_MON: J303.16, J304.8, R1701.2, U305.10 (5Y)
/U301 — WD1772 and port/DRV_STEP: J303.20, J304.10, RN1703.2 (R2.1)
/U301 — WD1772 and port/DRV_WDATA: J303.22, J304.11, RN1703.3 (R3.1)
/U301 — WD1772 and port/DRV_WGATE: J303.24, J304.12, RN1703.4 (R4.1)
/U301 — WD1772 and port/dirc: U301.17 (DIRC), U305.9 (4A)
/U301 — WD1772 and port/ip: J303.8, J304.4, RN1701.2 (R2.1), U301.24 (~IP)
/U301 — WD1772 and port/mo: U301.20 (MO), U305.11 (5A)
/U301 — WD1772 and port/not_dirc: RN1703.8 (R1.2), RN1704.1 (R1.1), U305.8 (4Y)
/U301 — WD1772 and port/not_step: RN1703.7 (R2.2), RN1704.2 (R2.1), U305.6 (3Y)
/U301 — WD1772 and port/not_wd: RN1703.6 (R3.2), RN1704.3 (R3.1), U305.4 (2Y)
/U301 — WD1772 and port/not_wg: RN1703.5 (R4.2), RN1704.4 (R4.1), U305.2 (1Y)
/U301 — WD1772 and port/rd: J303.30, J304.1, R307.2, U301.19 (~RD)
/U301 — WD1772 and port/step: U301.16 (STEP), U305.5 (3A)
/U301 — WD1772 and port/tr00: J303.26, J304.13, RN1701.3 (R3.1), U301.23 (~TR00)
/U301 — WD1772 and port/wd: U301.22 (WD), U305.3 (2A)
/U301 — WD1772 and port/wg: U301.21 (WG), U305.1 (1A)
/U301 — WD1772 and port/wprt: J303.28, J304.14, RN1701.1 (R1.1), U301.25 (~WPRT)
ACSI_19_HDRQ: RN1702.1 (R1.1), U305.13 (6A); also elsewhere on the board
CADDR1: U301.3 (A0); also elsewhere on the board
CADDR2: U301.4 (A1); also elsewhere on the board
CDATA0: U301.5 (DAL0); also elsewhere on the board
CDATA1: U301.6 (DAL1); also elsewhere on the board
CDATA2: U301.7 (DAL2); also elsewhere on the board
CDATA3: U301.8 (DAL3); also elsewhere on the board
CDATA4: U301.9 (DAL4); also elsewhere on the board
CDATA5: U301.10 (DAL5); also elsewhere on the board
CDATA6: U301.11 (DAL6); also elsewhere on the board
CDATA7: U301.12 (DAL7); also elsewhere on the board
D0SEL: J303.10, W301.1 (A); also elsewhere on the board
D1SEL: J303.12, W300.1 (A), W301.3 (C); also elsewhere on the board
DMA_FDCS: U301.1 (~CS); also elsewhere on the board
DMA_FDRQ: U301.27 (DRQ); also elsewhere on the board
DMA_HDRQ: RN1702.2 (R2.1), U305.12 (6Y); also elsewhere on the board
DMA_RW: U301.2 (R/~W); also elsewhere on the board
FDINT: U301.28 (INTRQ); also elsewhere on the board
GND: C304.2, C305.2, J302.2, J302.3, J303.1, J303.3, J303.5, J303.7, J303.9, J303.11, J303.13, J303.15, J303.17, J303.19, J303.21, J303.23, J303.25, J303.27, J303.29, J303.31, J303.33, J304.3, J304.7, J304.SH (Shield), U301.14 (GND), U301.26 (~DDEN), U305.7 (GND); also elsewhere on the board
unnamed: J304.5, W301.2 (B)
unnamed: J304.6, W300.2 (B)
unnamed: J1701.1, R1701.1
unnamed: J1701.3, RN1704.5 (R4.2), RN1704.6 (R3.2), RN1704.7 (R2.2), RN1704.8 (R1.2)
unnamed: R302.1, W300.3 (C)
S0SEL: J303.32, J304.2; also elsewhere on the board
SCLK: U301.18 (CLK); also elsewhere on the board
VCC: C304.1, C305.1, J302.1, J1701.2, J1701.4, R302.2, R307.1, RN1701.5 (R4.2), RN1701.6 (R3.2), RN1701.7 (R2.2), RN1701.8 (R1.2), RN1702.5 (R4.2), RN1702.6 (R3.2), RN1702.7 (R2.2), RN1702.8 (R1.2), U301.15 (Vcc), U305.14 (Vcc); also elsewhere on the board
XRESET: U301.13 (~MR); also elsewhere on the board

Notes on the sheet:
Factory setting : VCC
Factory setting : D1SEL
see https://www.exxoshost.co.uk/forum/viewtopic.php?f=17&t=1395

Schematic: subsheet_402.kicad_sch, ReSTe mignon

Parts:
C411, C414, C2101: 0.1uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C2102: 1uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
CP416, CP2101: 47uF; C_Radial_D6.3mm_H11.0mm_P2.50mm
FB401, FB402: Ferrite Bead; L_1206_3216Metric_Pad1.22x1.90mm_HandSolder
J400: DIN-13S — Video Port; socket-din-13
Q400, Q401, Q402, Q403: MMBT3904; SOT-23
R406, R413, R429, R440: 1K; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R407, R420, R432: 75; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R408, R423, R433: 2K; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R409, R425, R434: 150; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R431: 1K2; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R435, R437: 33; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R438: 27; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R441: 100; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R472: 4K7; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
U405: 74S257_PHY; DIP-16_W7.62mm_LongPads

Connections:
32MHZ: U405.3 (B1); also elsewhere on the board
/J400 — Video Port/+12V: R431.2
/J400 — Video Port/fvcc1: C411.1, C2102.1, CP2101.1, FB401.2, Q400.3 (C), Q401.3 (C), Q402.3 (C), R406.1, R413.1, R429.1
/J400 — Video Port/fvcc2: C414.1, FB402.2, Q403.3 (C)
/J400 — Video Port/genlock: J400.3, R472.2, U405.1 (SELECT)
/J400 — Video Port/vid4: J400.4, U405.2 (A1), U405.6 (B2)
/J400 — Video Port/vid6_green: J400.6, R420.1
/J400 — Video Port/vid7_red: J400.7, R407.1
/J400 — Video Port/vid10_blue: J400.10, R432.1
/J400 — Video Port/vid11_mono: J400.11, R438.1
AUDIO: CP416.1; also elsewhere on the board
AUDIOI: J400.5; also elsewhere on the board
COMPOSITE_OR_CSYNC: J400.2; also elsewhere on the board
GND: C411.2, C414.2, C2101.2, C2102.2, CP2101.2, J400.13, J400.SH (Shield), R408.2, R409.2, R423.2, R425.2, R433.2, R434.2, R440.2, R441.2, U405.8 (GND), U405.10 (B3), U405.11 (A3), U405.13 (B4), U405.14 (A4), U405.15 (~CONTROL); also elsewhere on the board
HSYNC: R437.2; also elsewhere on the board
MC: U405.4 (Y1); also elsewhere on the board
MONOMON: U405.7 (Y2); also elsewhere on the board
unnamed: CP416.2, J400.1
unnamed: J400.8, R431.1
unnamed: J400.9, R437.1
unnamed: J400.12, R435.1
unnamed: Q400.1 (E), R407.2, R409.1
unnamed: Q401.1 (E), R420.2, R425.1
unnamed: Q402.1 (E), R432.2, R434.1
unnamed: Q403.1 (E), R438.2, R441.1
SHIFTER_BLUE: Q402.2 (B), R429.2, R433.1; also elsewhere on the board
SHIFTER_GREEN: Q401.2 (B), R413.2, R423.1; also elsewhere on the board
SHIFTER_MONO: Q403.2 (B), R440.1; also elsewhere on the board
SHIFTER_RED: Q400.2 (B), R406.2, R408.1; also elsewhere on the board
VCC: C2101.1, FB401.1, FB402.1, R472.1, U405.5 (A2), U405.16 (VCC); also elsewhere on the board
VSYNC: R435.2; also elsewhere on the board

Notes on the sheet:
It may also be a 74F257
Video ghosting fix : A 47uF low ESR electrolytic capacitor and a 1uF ceramic capacitor in parallel of C411 in parallel of C411. see https://www.exxoshost.co.uk/atari/last/VIDEOFIX/index.htm
Genlock is active low. -> When asserted (low), vid4 is the external video clock of the genlock, and sent as the main clock MC to the shifter ; MONOMON is forced to high (color display). -> When negated (high), the 32MHz clock is sent as the main clock MC to the shifter ; vid4 is the detection of mo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

Schematic: subsheet_403.kicad_sch, ReSTe mignon

Parts:
D401, D402: 1N914; D_SOD-123F
FB410: Ferrite Bead; L_1206_3216Metric_Pad1.22x1.90mm_HandSolder
Q405: MMBT3904; SOT-23
R473: 10K; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R474: 100; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R475: 150; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder

Connections:
COMPOSITE_OR_CSYNC: R474.1; also elsewhere on the board
GND: R475.2; also elsewhere on the board
HSYNC: D401.1 (K); also elsewhere on the board
unnamed: D401.2 (A), D402.2 (A), Q405.2 (B), R473.2
unnamed: FB410.2, Q405.3 (C), R473.1
unnamed: Q405.1 (E), R474.2, R475.1
VCC: FB410.1; also elsewhere on the board
VSYNC: D402.1 (K); also elsewhere on the board

Schematic: subsheet_500.kicad_sch, ReSTe mignon

Parts:
C526, C532, C539, C548: 800pF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C527, C533, C540, C549: 0.01uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C554, C555: 0.1uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
FB500, FB501, FB502, FB503, FB508: Ferrite Bead; L_1206_3216Metric_Pad1.22x1.90mm_HandSolder
J500: DM-15S — JOY0; DSUB-15-HD_Female_Horizontal_P2.29x1.98mm_EdgePinOffset8.35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
J501: DM-15S — JOY1; DSUB-15-HD_Female_Horizontal_P2.29x1.98mm_EdgePinOffset8.35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
R518, R521, R528, R535: 1M; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R519, R523, R529, R536: 470; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
U513, U514: LM556_DUAL_TIMER_PHY; DIP-14_W7.62mm_LongPads

Connections:
/J500 J501 — Gamepad ports/j0_5: C532.1, R523.2, U513.12 (2THRESHOLD), U513.13 (2DISCHARGE)
/J500 J501 — Gamepad ports/j0_15: C526.1, R519.2, U513.1 (1DISCHARGE), U513.2 (1THRESHOLD)
/J500 J501 — Gamepad ports/j1_5: C539.1, R529.2, U514.1 (1DISCHARGE), U514.2 (1THRESHOLD)
/J500 J501 — Gamepad ports/j1_15: C548.1, R536.2, U514.12 (2THRESHOLD), U514.13 (2DISCHARGE)
GND: C526.2, C527.2, C532.2, C533.1, C539.2, C540.2, C548.2, C549.2, C554.2, C555.2, J500.9, J500.SH (Shield), J501.9, J501.SH (Shield), U513.7 (GND), U514.7 (GND); also elsewhere on the board
JOY0_1: J500.1; also elsewhere on the board
JOY0_2: J500.2; also elsewhere on the board
JOY0_3: J500.3; also elsewhere on the board
JOY0_4: J500.4; also elsewhere on the board
JOY0_10: J500.10; also elsewhere on the board
JOY0_11: J500.11; also elsewhere on the board
JOY0_12: J500.12; also elsewhere on the board
JOY0_13: J500.13; also elsewhere on the board
JOY0_14: J500.14; also elsewhere on the board
JOY1_1: J501.1; also elsewhere on the board
JOY1_2: J501.2; also elsewhere on the board
JOY1_3: J501.3; also elsewhere on the board
JOY1_4: J501.4; also elsewhere on the board
JOY1_6: J501.6; also elsewhere on the board
JOY1_10: J501.10; also elsewhere on the board
JOY1_11: J501.11; also elsewhere on the board
JOY1_12: J501.12; also elsewhere on the board
JOY1_13: J501.13; also elsewhere on the board
JOY1_14: J501.14; also elsewhere on the board
unnamed: FB500.2, R518.2, R519.1
unnamed: FB501.2, R521.2, R523.1
unnamed: FB502.2, R528.2, R529.1
unnamed: FB503.2, R535.2, R536.1
unnamed: FB500.1, J500.5
unnamed: FB508.1, J500.6
unnamed: FB501.1, J500.15
unnamed: FB502.1, J501.5
unnamed: FB503.1, J501.15
unnamed: C527.1, U513.3 (1CTLVLT)
unnamed: C533.2, U513.11 (2CTLVLT)
unnamed: C540.1, U514.3 (1CTLVLT)
unnamed: C549.1, U514.11 (2CTLVLT)
VCC: C554.1, C555.1, J500.7, J501.7, R518.1, R521.1, R528.1, R535.1, U513.4 (~1RESET), U513.10 (~2RESET), U513.14 (Vcc), U514.4 (~1RESET), U514.10 (~2RESET), U514.14 (Vcc); also elsewhere on the board
XPAD0X: U513.5 (1OUTPUT); also elsewhere on the board
XPAD0Y: U513.9 (2OUTPUT); also elsewhere on the board
XPAD1X: U514.5 (1OUTPUT); also elsewhere on the board
XPAD1Y: U514.9 (2OUTPUT); also elsewhere on the board
XPADRST: U513.6 (1TRIGGER), U513.8 (2TRIGGER), U514.6 (1TRIGGER), U514.8 (2TRIGGER); also elsewhere on the board
XPEN: FB508.2; also elsewhere on the board

Notes on the sheet:
Note : I swapped R518 and R521, as well as R519 and R523, to match what I have on my motherboard.

Schematic: subsheet_501.kicad_sch, ReSTe mignon

Parts:
C550, C551, C552, C553: 0.1uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
RN2401, RN2402, RN2403, RN2404, RN2405, RN2406: 4K7 ×4; R_Array_Convex_4x0603
U509, U510, U512: 74LS244_PHY; DIP-20_W7.62mm_LongPads
U511: 74LS373_PHY; DIP-20_W7.62mm_LongPads

Connections:
/U509~~U512 — Gamepad control/pull_500_2: RN2401.1 (R1.1), U509.2 (1A1)
/U509~~U512 — Gamepad control/pull_500_4: RN2401.3 (R3.1), U509.4 (1A2)
/U509~~U512 — Gamepad control/pull_500_6: RN2402.1 (R1.1), U509.6 (1A3)
/U509~~U512 — Gamepad control/pull_500_8: RN2402.3 (R3.1), U509.8 (1A4)
DATA0: U509.3 (2Y4), U510.18 (1Y1), U511.3 (1D); also elsewhere on the board
DATA1: U509.5 (2Y3), U510.16 (1Y2), U511.4 (2D); also elsewhere on the board
DATA2: U509.7 (2Y2), U510.14 (1Y3), U511.7 (3D); also elsewhere on the board
DATA3: U509.9 (2Y1), U510.12 (1Y4), U511.8 (4D); also elsewhere on the board
DATA4: U509.12 (1Y4), U510.9 (2Y1), U511.13 (5D); also elsewhere on the board
DATA5: U509.14 (1Y3), U510.7 (2Y2), U511.14 (6D); also elsewhere on the board
DATA6: U509.16 (1Y2), U510.5 (2Y3), U511.17 (7D); also elsewhere on the board
DATA7: U509.18 (1Y1), U510.3 (2Y4), U511.18 (8D); also elsewhere on the board
DATA8: U512.18 (1Y1); also elsewhere on the board
DATA9: U512.16 (1Y2); also elsewhere on the board
DATA10: U512.14 (1Y3); also elsewhere on the board
DATA11: U512.12 (1Y4); also elsewhere on the board
DATA12: U512.9 (2Y1); also elsewhere on the board
DATA13: U512.7 (2Y2); also elsewhere on the board
DATA14: U512.5 (2Y3); also elsewhere on the board
DATA15: U512.3 (2Y4); also elsewhere on the board
GND: C550.2, C551.2, C552.2, C553.2, U509.10 (GND), U510.10 (GND), U511.10 (GND), U512.10 (GND); also elsewhere on the board
JOY0_1: RN2404.3 (R3.1), U510.8 (1A4), U511.9 (4Q); also elsewhere on the board
JOY0_2: RN2404.1 (R1.1), U510.6 (1A3), U511.6 (3Q); also elsewhere on the board
JOY0_3: RN2403.3 (R3.1), U510.4 (1A2), U511.5 (2Q); also elsewhere on the board
JOY0_4: RN2403.1 (R1.1), U510.2 (1A1), U511.2 (1Q); also elsewhere on the board
JOY0_10: RN2401.4 (R4.1), U509.15 (2A3); also elsewhere on the board
JOY0_11: RN2406.3 (R3.1), U512.8 (1A4); also elsewhere on the board
JOY0_12: RN2406.1 (R1.1), U512.6 (1A3); also elsewhere on the board
JOY0_13: RN2405.3 (R3.1), U512.4 (1A2); also elsewhere on the board
JOY0_14: RN2405.1 (R1.1), U512.2 (1A1); also elsewhere on the board
JOY1_1: RN2403.2 (R2.1), U510.17 (2A4), U511.19 (8Q); also elsewhere on the board
JOY1_2: RN2403.4 (R4.1), U510.15 (2A3), U511.16 (7Q); also elsewhere on the board
JOY1_3: RN2404.2 (R2.1), U510.13 (2A2), U511.15 (6Q); also elsewhere on the board
JOY1_4: RN2404.4 (R4.1), U510.11 (2A1), U511.12 (5Q); also elsewhere on the board
JOY1_6: RN2402.2 (R2.1), U509.13 (2A2); also elsewhere on the board
JOY1_10: RN2402.4 (R4.1), U509.11 (2A1); also elsewhere on the board
JOY1_11: RN2405.2 (R2.1), U512.17 (2A4); also elsewhere on the board
JOY1_12: RN2405.4 (R4.1), U512.15 (2A3); also elsewhere on the board
JOY1_13: RN2406.2 (R2.1), U512.13 (2A2); also elsewhere on the board
JOY1_14: RN2406.4 (R4.1), U512.11 (2A1); also elsewhere on the board
JOYWL: U511.11 (C); also elsewhere on the board
VCC: C550.1, C551.1, C552.1, C553.1, RN2401.5 (R4.2), RN2401.6 (R3.2), RN2401.7 (R2.2), RN2401.8 (R1.2), RN2402.5 (R4.2), RN2402.6 (R3.2), RN2402.7 (R2.2), RN2402.8 (R1.2), RN2403.5 (R4.2), RN2403.6 (R3.2), RN2403.7 (R2.2), RN2403.8 (R1.2), RN2404.5 (R4.2), RN2404.6 (R3.2), RN2404.7 (R2.2), RN2404.8 (R1.2), RN2405.5 (R4.2), RN2405.6 (R3.2), RN2405.7 (R2.2), RN2405.8 (R1.2), RN2406.5 (R4.2), RN2406.6 (R3.2), RN2406.7 (R2.2), RN2406.8 (R1.2), U509.20 (Vcc), U510.20 (Vcc), U511.20 (VCC), U512.20 (Vcc); also elsewhere on the board
XBUTTON: U509.1 (~1G), U509.19 (~2G); also elsewhere on the board
XJOYRH: U512.1 (~1G), U512.19 (~2G); also elsewhere on the board
XJOYRL: U510.1 (~1G), U510.19 (~2G); also elsewhere on the board
XJOYWE: U511.1 (~OC); also elsewhere on the board
XPEN: RN2401.2 (R2.1), U509.17 (2A4); also elsewhere on the board

Notes on the sheet:
JOY1_11 to JOY1_14 are in reversed order, to match the wiring on my motherboard.
D4 to D7 are in reversed order, to match the wiring on my motherboard.

Schematic: subsheet_502.kicad_sch, ReSTe mignon

Parts:
C503, C515: 0.01uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C504, C507, C516, C519, C556, C557, C559, C562: 0.1uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
CP558, CP561: 100uF; C_Radial_D8.0mm_H11.5mm_P3.50mm
R500, R508, R509, R517: 8K2 1%; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R505, R514: 10K; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R506, R515: 10K 1%; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R542, R543: 10; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
U500, U501: 74F374_OCTAL_D-TYPE_EDGE-TRIGGERED_FLIP-FLOP_PHY; DIP-20_W7.62mm_LongPads
U502, U503: DAC0802LCN_PHY; DIP-16_W7.62mm_LongPads

Connections:
-5V: R543.2; also elsewhere on the board
/U500~~U503 - DMA Sound DAC/left_b1: U500.2 (1Q), U502.5 (B1)
/U500~~U503 - DMA Sound DAC/left_b2: U500.5 (2Q), U502.6 (B2)
/U500~~U503 - DMA Sound DAC/left_b3: U500.6 (3Q), U502.7 (B3)
/U500~~U503 - DMA Sound DAC/left_b4: U500.9 (4Q), U502.8 (B4)
/U500~~U503 - DMA Sound DAC/left_b5: U500.12 (5Q), U502.9 (B5)
/U500~~U503 - DMA Sound DAC/left_b6: U500.15 (6Q), U502.10 (B6)
/U500~~U503 - DMA Sound DAC/left_b7: U500.16 (7Q), U502.11 (B7)
/U500~~U503 - DMA Sound DAC/left_b8: U500.19 (8Q), U502.12 (B8)
/U500~~U503 - DMA Sound DAC/right_b1: U501.2 (1Q), U503.5 (B1)
/U500~~U503 - DMA Sound DAC/right_b2: U501.5 (2Q), U503.6 (B2)
/U500~~U503 - DMA Sound DAC/right_b3: U501.6 (3Q), U503.7 (B3)
/U500~~U503 - DMA Sound DAC/right_b4: U501.9 (4Q), U503.8 (B4)
/U500~~U503 - DMA Sound DAC/right_b5: U501.12 (5Q), U503.9 (B5)
/U500~~U503 - DMA Sound DAC/right_b6: U501.15 (6Q), U503.10 (B6)
/U500~~U503 - DMA Sound DAC/right_b7: U501.16 (7Q), U503.11 (B7)
/U500~~U503 - DMA Sound DAC/right_b8: U501.19 (8Q), U503.12 (B8)
DAC_LEFT: R508.2, U502.2 (~IOUT); also elsewhere on the board
DAC_RIGHT: R517.2, U503.2 (~IOUT); also elsewhere on the board
GND: C504.1, C507.2, C516.1, C519.2, C556.2, C557.2, C559.2, C562.2, CP558.2, CP561.2, R506.2, R515.2, U500.1 (~OC), U500.10 (GND), U501.1 (~OC), U501.10 (GND), U502.1 (THRS_CTL), U503.1 (THRS_CTL); also elsewhere on the board
unnamed: C503.1, U502.16 (COMPENSATION)
unnamed: R500.2, U502.4 (IOUT)
unnamed: R505.2, U502.14 (VREF+)
unnamed: R506.1, U502.15 (VREF-)
unnamed: C515.1, U503.16 (COMPENSATION)
unnamed: R509.2, U503.4 (IOUT)
unnamed: R514.2, U503.14 (VREF+)
unnamed: R515.1, U503.15 (VREF-)
SD0: U500.18 (8D), U501.18 (8D); also elsewhere on the board
SD1: U500.17 (7D), U501.17 (7D); also elsewhere on the board
SD2: U500.14 (6D), U501.14 (6D); also elsewhere on the board
SD3: U500.13 (5D), U501.13 (5D); also elsewhere on the board
SD4: U500.8 (4D), U501.8 (4D); also elsewhere on the board
SD5: U500.7 (3D), U501.7 (3D); also elsewhere on the board
SD6: U500.4 (2D), U501.4 (2D); also elsewhere on the board
SD7: U500.3 (1D), U501.3 (1D); also elsewhere on the board
VCC: C556.1, C557.1, R542.2, U500.20 (VCC), U501.20 (VCC); also elsewhere on the board
V_AUD+: C507.1, C519.1, C559.1, CP558.1, R500.1, R505.1, R508.1, R509.1, R514.1, R517.1, R542.1, U502.13 (V+), U503.13 (V+); also elsewhere on the board
V_AUD-: C503.2, C504.2, C515.2, C516.2, C562.1, CP561.1, R543.1, U502.3 (V-), U503.3 (V-); also elsewhere on the board
XLD: U500.11 (CLK); also elsewhere on the board
XRD: U501.11 (CLK); also elsewhere on the board

Notes on the sheet:
Ground plane this area
Use 1% resistors
